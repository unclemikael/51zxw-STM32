<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM32F10X Template.ewp</path>
    </project>
    <batchBuild />
</workspace>
